options:
  parameters:
    generate_options: qt_gui
    id: FMCW_radar_py
    output_language: python
    title: FMCW Radar Module
  states: {}

blocks:
- name: chirp_length
  id: variable
  parameters:
    value: '64'
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: '9'
  states: {}
- name: decimator_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e6
    win: firdes.WIN_HAMMING
  states: {}
- name: noise_level
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '0.01'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 28.8e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20.0e6
  states: {}
- name: target_distance
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '7.49'
    stop: '479.67'
    value: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: chirp_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate * 2 * target_distance / (3e8))
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/david/Documents/RadarSecurityResearch/FMCW_radar/FMCW_out.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/david/Documents/MATLAB_generated/chirp_samplePeriod.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/chirp_length
    type: complex
    vlen: chirp_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: chirp_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chirp_length
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chirp_length
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hanning(chirp_length)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation_factor
    taps: decimator_taps
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"IF Signal (decimated)"'
    size: chirp_length
    srate: samp_rate/decimation_factor
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Range Plot"'
    vlen: chirp_length
    x_axis_label: '"range"'
    x_start: '0'
    x_step: '7.49'
    x_units: '"m"'
    y_axis_label: '"magnitude"'
    y_units: '"dB"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '0'
    dev_args: '""'
    gain0: '50'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '50'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: decimated_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: decimated_sig
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    timeout: '100'
    type: complex
    vlen: chirp_length
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', fir_filter_xxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
